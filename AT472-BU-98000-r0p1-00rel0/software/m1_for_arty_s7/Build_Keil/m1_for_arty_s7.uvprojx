# Keil uVision project m1_for_arty_s7.uvprojx, settings and files
target m1_for_arty_s7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: m1_for_arty_s7 +hex
  AfterMake: make_hex_s7.bat
  c flags: Optim=2 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M1 ARTY_CM1
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM1;..\sdk_workspace\standalone_bsp_0\CORTEX_M1_0\include;..\main;..\gpio;..\uart;..\spi
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Reset_Handler
  group CMSIS
    ../cmsis/Device/Source/ARTY_CM1/: startup_ARTY_CM1.s system_ARTY_CM1.c
  group Standalone_v6_7
    ../sdk_workspace/standalone_bsp_0/Cortex_M1_0/libsrc/standalone_v6_7/src/: outbyte.c print.c xil_assert.c xil_printf.c
  group Main
    ../main/: main.c
  group GPIO
    ../gpio/: gpio.c
  group SPI
    ../spi/: spi.c
  group UART
    ../uart/: uart.c
  group Xilinx_GPIO
    ../sdk_workspace/standalone_bsp_0/Cortex_M1_0/libsrc/gpio_v4_3/src/: xgpio.c xgpio_extra.c xgpio_g.c xgpio_intr.c xgpio_selftest.c xgpio_sinit.c
  group Xilinx_SPI
    ../sdk_workspace/standalone_bsp_0/Cortex_M1_0/libsrc/spi_v4_4/src/: xspi.c xspi_g.c xspi_options.c xspi_selftest.c xspi_sinit.c xspi_stats.c
  group Xilinx_UART
    ../sdk_workspace/standalone_bsp_0/Cortex_M1_0/libsrc/uartlite_v3_2/src/: xuartlite.c xuartlite_g.c xuartlite_intr.c xuartlite_l.c xuartlite_selftest.c xuartlite_sinit.c xuartlite_stats.c
  group Xilinx_PmodHYGRO
    ../sdk_workspace/standalone_bsp_0/CORTEX_M1_0/libsrc/PmodHYGRO_v1_0/src/: PmodHYGRO.c xiic.c xiic_dyn_master.c xiic_intr.c xiic_l.c xiic_master.c xiic_multi_master.c xiic_options.c xiic_selftest.c xiic_slave.c xiic_stats.c xtmrctr.c xtmrctr_intr.c xtmrctr_l.c xtmrctr_options.c xtmrctr_selftest.c xtmrctr_sinit.c xtmrctr_stats.c
  group Xilinx_PmodNAV
    ../sdk_workspace/standalone_bsp_0/CORTEX_M1_0/libsrc/PmodNAV_v1_0/src/: PmodNAV.c
software components: CMSIS:CORE 5.0.2
